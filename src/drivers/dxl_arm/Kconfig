## src/drivers/dxl_arm/Kconfig
```kconfig
menuconfig DRIVERS_DXL_ARM
	bool "dxl_arm"
	default n
	---help---
		Enable support for Dynamixel XL430 arm driver over UART
```
